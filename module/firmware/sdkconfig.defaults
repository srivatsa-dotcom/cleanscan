## module/firmware/sdkconfig.defaults
```kconfig
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192
CONFIG_FREERTOS_HZ=1000
CONFIG_LWIP_UDP_RECVMBOX_SIZE=16
CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
```
